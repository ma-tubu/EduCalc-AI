# Keil uVision project HandExprJudge.uvprojx, settings and files
target HandExprJudge (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: HandExprJudge +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\Core\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\ST\AI\Inc;..\X-CUBE-AI\App
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: HandExprJudge.sct
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/User/AppModules
    ../Core/Inc/: app_config.h app_controller.h ai_infer.h image_segment.h expr_judge.h
    ../Core/Src/: app_controller.c ai_infer.c image_segment.c expr_judge.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
software components: CMSIS:CORE 4.3.0
